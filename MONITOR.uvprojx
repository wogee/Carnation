# Keil uVision project MONITOR.uvprojx, settings and files
target MONITOR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MONITOR +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NO_CRP,__RUN_ADDR
  c include: .\CODE;.\CODE\CONFIG;.\CODE\BOARD\CM3;.\CODE\BOARD;.\CODE\BOARD\LPC177x_8x;.\CODE\BOARD\DRIVER;.\CODE\OS\;.\CODE\OS\uCOS-II;.\CODE\OS\uCOS-II\Ports;.\CODE\OS\uCOS-II\Source;.\CODE\APP;.\CODE\APP\LIB;.\CODE\APP\NET;.\CODE\APP\CHG;.\CODE\APP\MAINPROC;.\CODE\APP\EXT_CHG
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group APP
    ./CODE/APP/: App.c MyAlgLib.c Para.c CardTask.c ElmTask.c Record.c Protocol.c ChgInterface.c DisPlay.c
    ./CODE/APP/MAINPROC/: MainTask.c
    ./CODE/APP/LIB/: ENCRYPT.lib USBFS10.lib
  group BOARD
    ./CODE/BOARD/: Board.c IAP.c
    ./CODE/BOARD/LPC177x_8x/: system_LPC177x_8x.c startup_LPC177x_8x.s
    ./CODE/BOARD/CM3/: core_cm3.c
    ./CODE/BOARD/DRIVER/: AD.c BUZZER.c CAN.c FRAM.c GPIO.C LED.c MODEM.c RS485.c RTC.c SPI.c TIMER.c UART.c WDG.c DWIN.c MT625.c EEPROM.c RELAY.c xrd.c
  group CONFIG
    ./CODE/CONFIG/: Cfg.h
  group OS
    ./CODE/OS/uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm
    ./CODE/OS/uCOS-II/Source/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group APP_NET
    ./CODE/APP/NET/: ethernet.c gprs.c NetTask.c socket.c W5500.c wizchip_conf.c
  group APP_EXT_CHG
    ./CODE/APP/EXT_CHG/: EXT_ChgTask.c
